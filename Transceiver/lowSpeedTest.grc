options:
  parameters:
    generate_options: qt_gui
    id: lowSpeedTest
    output_language: python
    title: YoMama
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 5.8*10**9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {}
- name: variable_function_probe_1
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_2
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_2
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_function_probe_3
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_3
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0
    label: 'Rx1  '
    type: real
    value: variable_function_probe_0
  states: {}
- name: variable_qtgui_label_1
  id: variable_qtgui_label
  parameters:
    label: 'Rx2  '
    type: real
    value: variable_function_probe_1
  states: {}
- name: variable_qtgui_label_2
  id: variable_qtgui_label
  parameters:
    label: 'Rx3  '
    type: real
    value: variable_function_probe_2
  states: {}
- name: variable_qtgui_label_3
  id: variable_qtgui_label
  parameters:
    label: 'Rx4  '
    type: real
    value: variable_function_probe_3
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_conjugate_cc_0_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_conjugate_cc_0_1
  id: blocks_conjugate_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_conjugate_cc_0_2
  id: blocks_conjugate_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '50000'
    max_iter: '4000'
    scale: 20*10**(-6)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '50000'
    max_iter: '4000'
    scale: 20*10**(-6)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1
  id: blocks_moving_average_xx
  parameters:
    length: '50000'
    max_iter: '4000'
    scale: 20*10**(-6)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_2
  id: blocks_moving_average_xx
  parameters:
    length: '50000'
    max_iter: '4000'
    scale: 20*10**(-6)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_2
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_1
  id: blocks_probe_signal_vx
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_2
  id: blocks_probe_signal_vx
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_3
  id: blocks_probe_signal_vx
  parameters:
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    plotfreq: 'False'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_3
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    ant2: '"RX2"'
    ant3: '"RX2"'
    bw0: bw
    bw1: bw
    bw2: bw
    bw3: bw
    center_freq0: fc
    center_freq1: fc
    center_freq2: fc
    center_freq3: fc
    dev_addr: '"addr=192.168.1.2"'
    gain0: '10'
    gain1: '10'
    gain2: '10'
    gain3: '10'
    nchan: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    start_time: '5'
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_moving_average_xx_0_1, '0']
- [blocks_complex_to_mag_squared_0_2, '0', blocks_moving_average_xx_0_2, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_conjugate_cc_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_conjugate_cc_0_1, '0', blocks_multiply_xx_0_1, '1']
- [blocks_conjugate_cc_0_2, '0', blocks_multiply_xx_0_2, '1']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_moving_average_xx_0_1, '0', blocks_nlog10_ff_0_1, '0']
- [blocks_moving_average_xx_0_2, '0', blocks_nlog10_ff_0_2, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_sink_x_1, '0']
- [blocks_multiply_xx_0_1, '0', qtgui_sink_x_2, '0']
- [blocks_multiply_xx_0_2, '0', qtgui_sink_x_3, '0']
- [blocks_nlog10_ff_0, '0', blocks_probe_signal_x_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_probe_signal_x_1, '0']
- [blocks_nlog10_ff_0_1, '0', blocks_probe_signal_x_2, '0']
- [blocks_nlog10_ff_0_2, '0', blocks_probe_signal_x_3, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', blocks_conjugate_cc_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0_2, '0']
- [uhd_usrp_source_0, '1', blocks_complex_to_mag_squared_0_0, '0']
- [uhd_usrp_source_0, '2', blocks_complex_to_mag_squared_0_1, '0']
- [uhd_usrp_source_0, '3', blocks_complex_to_mag_squared_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
