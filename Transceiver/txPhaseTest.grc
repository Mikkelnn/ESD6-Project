options:
  parameters:
    generate_options: qt_gui
    id: txPhaseTest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 50*10**6
  states: {}
- name: fc
  id: variable
  parameters:
    value: 5.8*10**9
  states: {}
- name: gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2*10**6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    ant2: '"TX/RX"'
    ant3: '"TX/RX"'
    bw0: bw
    bw1: bw
    bw2: bw
    bw3: bw
    center_freq0: fc
    center_freq1: fc
    center_freq2: fc
    center_freq3: fc
    clock_source0: external
    dev_addr: '"addr=192.168.1.2"'
    gain0: '0'
    gain1: '0'
    gain2: '0'
    gain3: '0'
    gain_type0: power
    gain_type1: power
    gain_type2: power
    gain_type3: power
    nchan: '4'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0_0, '0', uhd_usrp_sink_0, '1']
- [analog_sig_source_x_0_1, '0', uhd_usrp_sink_0, '2']
- [analog_sig_source_x_0_2, '0', uhd_usrp_sink_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
