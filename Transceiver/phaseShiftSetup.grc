options:
  parameters:
    author: theil
    generate_options: qt_gui
    id: phaseShiftSetup
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 10**6
  states: {}
- name: fc
  id: variable
  parameters:
    value: 5.8*10**9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30*10**6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '3.14'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '4.61'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '1.56'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_1
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_1_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    nconnections: '4'
    size: '1024'
    type: complex
    xmax: '0.0001'
    xmin: '-0.0001'
    ymax: '0.0001'
    ymin: '-0.0001'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    ant1: '"RX1"'
    ant2: '"RX1"'
    ant3: '"RX1"'
    bw0: bw
    bw1: bw
    bw2: bw
    center_freq0: fc
    center_freq1: fc
    center_freq2: fc
    center_freq3: fc
    dev_addr: '"addr=192.168.1.2"'
    gain0: '0'
    gain1: '0'
    gain2: '0'
    gain3: bw
    nchan: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sd_spec0: A:0 A:1 B:0 B:1
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_conjugate_cc_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_conjugate_cc_1, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_conjugate_cc_0_0, '0']
- [analog_sig_source_x_0_0_1, '0', blocks_conjugate_cc_1_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_conjugate_cc_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_conjugate_cc_1, '0', blocks_multiply_xx_1, '1']
- [blocks_conjugate_cc_1_0, '0', blocks_multiply_xx_1_0, '1']
- [blocks_multiply_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_const_sink_x_0, '2']
- [blocks_multiply_xx_1, '0', qtgui_const_sink_x_0, '1']
- [blocks_multiply_xx_1_0, '0', qtgui_const_sink_x_0, '3']
- [uhd_usrp_source_0, '0', blocks_conjugate_cc_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_1, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_1_0, '0']
- [uhd_usrp_source_0, '1', blocks_conjugate_cc_1, '0']
- [uhd_usrp_source_0, '2', blocks_conjugate_cc_0_0, '0']
- [uhd_usrp_source_0, '3', blocks_conjugate_cc_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
