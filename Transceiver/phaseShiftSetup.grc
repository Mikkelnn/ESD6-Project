options:
  parameters:
    author: theil
    generate_options: qt_gui
    id: phaseShiftSetup
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 10*10**6
  states: {}
- name: fc
  id: variable
  parameters:
    value: 5.8*10**9
  states: {}
- name: gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_2
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_1
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_1_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: phaseShift.dat
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: phaseShift.dat
    type: float
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: phaseShift.dat
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: phaseShift.dat
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_1
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: phaseShift.dat
    type: float
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 1024*4
    type: float
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: 1024*4
    type: float
  states: {}
- name: blocks_head_0_0_0
  id: blocks_head
  parameters:
    num_items: 1024*4
    type: float
  states: {}
- name: blocks_head_0_0_0_0
  id: blocks_head
  parameters:
    num_items: 1024*4
    type: float
  states: {}
- name: blocks_head_0_0_0_1
  id: blocks_head
  parameters:
    num_items: 1024*4
    type: float
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    num_streams: '4'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: 4*2000
    type: float
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: 4*20000
    type: float
  states: {}
- name: blocks_skiphead_0_0_0
  id: blocks_skiphead
  parameters:
    num_items: 4*200000
    type: float
  states: {}
- name: blocks_skiphead_0_0_0_0
  id: blocks_skiphead
  parameters:
    num_items: 4*2000000
    type: float
  states: {}
- name: blocks_skiphead_0_0_0_1
  id: blocks_skiphead
  parameters:
    num_items: 4*20000000
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: bw
    fc: fc
    fftsize: '128'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: bw
    fc: fc
    fftsize: '128'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: bw
    fc: fc
    fftsize: '128'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_2
  id: qtgui_sink_x
  parameters:
    bw: bw
    fc: fc
    fftsize: '128'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    ant1: '"RX1"'
    ant2: '"RX1"'
    ant3: '"RX1"'
    bw0: bw
    bw1: bw
    bw2: bw
    bw3: bw
    center_freq0: fc
    center_freq1: fc
    center_freq2: fc
    center_freq3: fc
    clock_source0: external
    dev_addr: '"addr=192.168.1.2"'
    gain0: gain
    gain1: gain
    gain2: gain
    gain3: gain
    nchan: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_complex_to_arg_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_interleave_0, '1']
- [blocks_complex_to_arg_1, '0', blocks_interleave_0, '2']
- [blocks_complex_to_arg_2, '0', blocks_interleave_0, '3']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_conjugate_cc_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_conjugate_cc_1, '0', blocks_multiply_xx_1, '1']
- [blocks_conjugate_cc_1_0, '0', blocks_multiply_xx_1_0, '1']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_head_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_head_0_0_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [blocks_head_0_0_0_1, '0', blocks_file_sink_0_0_0_1, '0']
- [blocks_interleave_0, '0', blocks_skiphead_0, '0']
- [blocks_interleave_0, '0', blocks_skiphead_0_0, '0']
- [blocks_interleave_0, '0', blocks_skiphead_0_0_0, '0']
- [blocks_interleave_0, '0', blocks_skiphead_0_0_0_0, '0']
- [blocks_interleave_0, '0', blocks_skiphead_0_0_0_1, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_arg_1, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_sink_x_0_1, '0']
- [blocks_multiply_xx_1, '0', blocks_complex_to_arg_0_0, '0']
- [blocks_multiply_xx_1, '0', qtgui_sink_x_0_0, '0']
- [blocks_multiply_xx_1_0, '0', blocks_complex_to_arg_2, '0']
- [blocks_multiply_xx_1_0, '0', qtgui_sink_x_0_2, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [blocks_skiphead_0_0, '0', blocks_head_0_0, '0']
- [blocks_skiphead_0_0_0, '0', blocks_head_0_0_0, '0']
- [blocks_skiphead_0_0_0_0, '0', blocks_head_0_0_0_0, '0']
- [blocks_skiphead_0_0_0_1, '0', blocks_head_0_0_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_conjugate_cc_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_1, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_1_0, '0']
- [uhd_usrp_source_0, '1', blocks_conjugate_cc_1, '0']
- [uhd_usrp_source_0, '2', blocks_conjugate_cc_0_0, '0']
- [uhd_usrp_source_0, '3', blocks_conjugate_cc_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
