options:
  parameters:
    generate_options: qt_gui
    id: USRPrx
    output_language: python
    title: USRP_rx_test
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 10*10**6
  states: {}
- name: fc
  id: variable
  parameters:
    value: 5.8*10**9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30*10**6
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: bw
    fc: fc
    fftsize: '1024'
    plotwaterfall: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: bw
    center_freq0: fc
    dev_addr: '"addr=192.168.10.2"'
    gain0: '0'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
